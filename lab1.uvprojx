# Keil uVision project lab1.uvprojx, settings and files
target FreeRTOS_Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab1
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F407xx,USE_STDPERIPH_DRIVER,STM32F4XX,KEIL_IDE,KEIL_ARMCM4F,HSE_VALUE=8000000,PLL_M=8,PLL_N=336,PLL_P=2,PLL_Q=7
  c include: .\src;.\src\FreeRTOS\include;.\src\FreeRTOS\portable\keil\ARM_CM4F;.\Libraries\CMSIS\Include;.\Libraries\Device;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Libraries\STM32F4DISCOVERY;.\Libraries;..\BDC_V1.0;..\BDC_V1.0
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./src/: main.c read_values.c in_out_periph.c lcd.c serial.c delay.c
  group FreeRTOS
    ./src/FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
    ./src/FreeRTOS/portable/MemMang/: heap_2.c
    ./src/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group StdPeriph Drivers
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_iwdg.c stm32f4xx_exti.c
  group STM32F4
    ./src/: stm32f4_discovery_lis302dl.c stm32f4xx_it.c utils.c retarget.c
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4_discovery.c
software components: Device:Startup 2.5.0
